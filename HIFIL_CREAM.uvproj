# Keil uVision project HIFIL_CREAM.uvproj, settings and files
target Target 1 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MODP2
  output: HIFIL_CREAMT01 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./SRC/: STARTUP.A51 main.c init.c int.c key.C util.c disp.c uart.c
